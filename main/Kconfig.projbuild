## main/Kconfig.projbuild
```kconfig
menu "Matter RGB bulb"
config BULB_DEVELOP
    bool "Development logging"
    default y
endmenu
```
